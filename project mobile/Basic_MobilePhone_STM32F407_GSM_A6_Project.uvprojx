# Keil uVision project Basic_MobilePhone_STM32F407_GSM_A6_Project.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARM_Compiler_5.06u7)
  device: STM32F407VGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.17.1
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Basic_MobilePhone_STM32F407_GSM_A6_Project
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\Basic_MobilePhone_STM32F407_GSM_A6_Project
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group User Application
    ./: main.c
  group GSM_A6_Driver
    ./: GSM_A6_Driver_STM32F407.c GSM_A6_Driver_STM32F407.h
  group LCD_Driver
    ./: STM32F407_I2C_LCD16x02_Driver.c STM32F407_I2C_LCD16x02_Driver.h
  group Keypad_Driver
    ./: STM32F407_KeypadDriver.c STM32F407_KeypadDriver.h
software components: CMSIS:CORE 5.3.0, Device:STM32Cube Framework:Classic 1.7.6, Device:STM32Cube HAL:Common 1.7.6, Device:STM32Cube HAL:Cortex 1.7.6, Device:STM32Cube HAL:DMA 1.7.6, Device:STM32Cube HAL:GPIO 1.7.6, Device:STM32Cube HAL:I2C 1.7.6, Device:STM32Cube HAL:PWR 1.7.6, Device:STM32Cube HAL:RCC 1.7.6, Device:STM32Cube HAL:UART 1.7.6, Device:Startup 2.6.3
